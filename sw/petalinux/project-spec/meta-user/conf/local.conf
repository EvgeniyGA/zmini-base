## sw/petalinux/project-spec/meta-user/conf/local.conf
```bitbake
BBLAYERS += " ${TOPDIR}/meta-openembedded/meta-python"
BBLAYERS += " ${TOPDIR}/project-spec/meta-mylayer"
```
